# Keil uVision project lib_lpcspifi_M4F.uvproj, settings and files
target lib_lpcspifi_M4F (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: lib_lpcspifi_M4F (library)
  AfterMake: cmd /c copy !L ..\lib\keil
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M4
  c misc: --gnu
  c include: .\;..\inc
  group src
    ../src/: spifilib_dev_common.c spifilib_fam_spa_2b_pstat.c spifilib_fam_spa_3b_stat.c spifilib_fam_mac_2b_stat.c
