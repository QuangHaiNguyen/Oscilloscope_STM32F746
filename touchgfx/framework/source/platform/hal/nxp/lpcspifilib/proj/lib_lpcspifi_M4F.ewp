# IAR project lib_lpcspifi_M4F.ewp, settings and files
configuration lib_lpcspifi_M4F (ARM)
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CORE_M3
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  postbuild: cmd /c copy iar_output\lib_lpcspifi_M4F\Exe\lib_lpcspifi_M4F.a ..\lib\IAR
  ILINK.IlinkOutputFile: lib_lpcspifi_18xx.out
  group src
    ../src/: spifilib_dev_common.c spifilib_fam_mac_2b_stat.c spifilib_fam_spa_2b_pstat.c spifilib_fam_spa_3b_stat.c
