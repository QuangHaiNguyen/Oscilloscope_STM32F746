# Keil uVision project lib_lpcspifi_M3_PI.uvproj, settings and files
target lib_lpcspifi_M3_PI (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: lib_lpcspifi_M3_PI (library)
  AfterMake: cmd /c copy !L ..\lib\keil
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c misc: --gnu --lower_ropi
  c include: .\;..\inc
  group src
    ../src/: spifilib_dev_common.c spifilib_fam_spa_3b_stat.c spifilib_fam_spa_2b_pstat.c spifilib_fam_mac_2b_stat.c
